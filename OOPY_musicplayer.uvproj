# Keil uVision project OOPY_musicplayer.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MicroSD
  c flags: OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\library\inc;..\OOPY_MUSIC_PLAYER_PCM1793_003;.\BOARD_SZ_LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20002000 size 0xe000
  group MAIN
    ./: main.c sdcard.c stm32f10x_it.c stm32f10x_vector.s cortexm3_macro.s bmpicon.c
  group LIB
    ./library/src/: stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_lib.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_nvic.c stm32f10x_usart.c
  group FATFS
    ./FATFS/: cc936.c diskio.c ff.c
  group TFT
    ./TFT/: fsmc_lcd.c tft_otm3225.c LCD_Printf.c
  group FLAC
    ./flac/: bitstream.c crc8.c flacdecoder.c flacplay.c golomb.c subframe_decoders.c
  group WAV
    ./WAV/: wavplay.c
  group BOARD_SZ_LIB
    ./BOARD_SZ_LIB/: LED.c debug.c
